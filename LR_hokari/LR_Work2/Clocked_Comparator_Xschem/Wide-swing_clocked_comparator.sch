v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
P 4 1 -200 240 {}
P 4 1 -390 -200 {}
N 110 -430 410 -430 {lab=VDD}
N 410 -430 480 -430 {lab=VDD}
N 480 -430 820 -430 {lab=VDD}
N -340 -410 -50 -410 {lab=PD}
N 1340 -400 1460 -400 {lab=RST}
N 1620 -380 1680 -380 {lab=#net1}
N 1790 -380 1830 -380 {lab=#net2}
N 1830 -380 2000 -380 {lab=#net2}
N -130 -370 -90 -370 {lab=VDD}
N -90 -370 0 -370 {lab=VDD}
N 0 -370 20 -370 {lab=VDD}
N 20 -370 40 -370 {lab=VDD}
N 110 -430 110 -370 {lab=VDD}
N 40 -370 110 -370 {lab=VDD}
N 110 -370 180 -370 {lab=VDD}
N 180 -370 210 -370 {lab=VDD}
N 210 -370 310 -370 {lab=VDD}
N 660 -370 710 -370 {lab=VDD}
N 710 -370 760 -370 {lab=VDD}
N 820 -430 820 -370 {lab=VDD}
N 760 -370 820 -370 {lab=VDD}
N 820 -370 900 -370 {lab=VDD}
N 900 -370 950 -370 {lab=VDD}
N 950 -370 990 -370 {lab=VDD}
N 660 -370 660 -360 {lab=VDD}
N 760 -370 760 -360 {lab=VDD}
N 900 -370 900 -360 {lab=VDD}
N 990 -370 990 -360 {lab=VDD}
N 1340 -360 1400 -360 {lab=PD}
N 1400 -360 1460 -360 {lab=PD}
N 2160 -360 2230 -360 {lab=#net3}
N 2340 -360 2470 -360 {lab=#net4}
N 2930 -360 2990 -360 {lab=PD}
N -90 -370 -90 -340 {lab=VDD}
N -50 -410 -50 -340 {lab=PD}
N -50 -340 -40 -340 {lab=PD}
N 20 -370 20 -340 {lab=VDD}
N 0 -340 20 -340 {lab=VDD}
N 180 -370 180 -340 {lab=VDD}
N 1890 -340 2000 -340 {lab=PC1}
N 2630 -340 2730 -340 {lab=#net5}
N 3320 -340 3370 -340 {lab=#net6}
N 3480 -340 3560 -340 {lab=#net7}
N 3670 -340 3780 -340 {lab=#net8}
N 3890 -340 4020 -340 {lab=#net9}
N 4130 -340 4160 -340 {lab=OUT1}
N 4160 -340 4190 -340 {lab=OUT1}
N 500 -330 610 -330 {lab=CLK}
N 610 -330 620 -330 {lab=CLK}
N 710 -370 710 -330 {lab=VDD}
N 660 -330 710 -330 {lab=VDD}
N 710 -330 760 -330 {lab=VDD}
N 800 -330 810 -330 {lab=PC1}
N 830 -330 860 -330 {lab=PC2}
N 950 -370 950 -330 {lab=VDD}
N 900 -330 950 -330 {lab=VDD}
N 950 -330 990 -330 {lab=VDD}
N 1030 -330 1050 -330 {lab=CLK}
N 2410 -320 2470 -320 {lab=#net10}
N 2890 -320 2940 -320 {lab=#net11}
N 2940 -320 2990 -320 {lab=#net11}
N -130 -370 -130 -310 {lab=VDD}
N -130 -310 -90 -310 {lab=VDD}
N -50 -310 0 -310 {lab=#net12}
N 0 -310 140 -310 {lab=#net12}
N 210 -370 210 -310 {lab=VDD}
N 180 -310 210 -310 {lab=VDD}
N 810 -330 810 -310 {lab=PC1}
N 810 -310 850 -310 {lab=PC1}
N -560 -300 -520 -300 {lab=PD}
N -340 -410 -340 -300 {lab=PD}
N -520 -300 -340 -300 {lab=PD}
N -340 -300 -180 -300 {lab=PD}
N -180 -300 -130 -300 {lab=PD}
N 660 -300 660 -290 {lab=PC2}
N 760 -300 760 -290 {lab=PC2}
N 660 -290 760 -290 {lab=PC2}
N 830 -330 830 -290 {lab=PC2}
N 760 -290 830 -290 {lab=PC2}
N 850 -310 850 -290 {lab=PC1}
N 900 -300 900 -290 {lab=PC1}
N 850 -290 900 -290 {lab=PC1}
N 990 -300 990 -290 {lab=PC1}
N 900 -290 990 -290 {lab=PC1}
N -130 -300 -130 -280 {lab=PD}
N 610 -330 610 -280 {lab=CLK}
N 1050 -330 1050 -280 {lab=CLK}
N 610 -280 1050 -280 {lab=CLK}
N 1400 -360 1400 -280 {lab=PD}
N 1400 -280 2000 -280 {lab=PD}
N -90 -280 -90 -270 {lab=#net12}
N -50 -310 -50 -270 {lab=#net12}
N -90 -270 -50 -270 {lab=#net12}
N 180 -280 180 -270 {lab=#net13}
N 20 -270 180 -270 {lab=#net13}
N 180 -270 330 -270 {lab=#net13}
N 2940 -320 2940 -270 {lab=#net11}
N 2840 -270 2940 -270 {lab=#net11}
N 900 -290 900 -260 {lab=PC1}
N 110 -260 900 -260 {lab=PC1}
N 900 -260 1080 -260 {lab=PC1}
N 1890 -340 1890 -260 {lab=PC1}
N 1080 -260 1890 -260 {lab=PC1}
N 2160 -260 2230 -260 {lab=#net14}
N 2410 -320 2410 -260 {lab=#net10}
N 2340 -260 2410 -260 {lab=#net10}
N 2730 -300 2730 -260 {lab=#net15}
N 2730 -260 2940 -260 {lab=#net15}
N 760 -290 760 -250 {lab=PC2}
N 240 -250 760 -250 {lab=PC2}
N 760 -250 1050 -250 {lab=PC2}
N 1050 -250 1100 -250 {lab=PC2}
N 2840 -270 2840 -250 {lab=#net11}
N 2730 -250 2840 -250 {lab=#net11}
N -310 -240 -280 -240 {lab=GND}
N -90 -270 -90 -240 {lab=#net12}
N -100 -240 -90 -240 {lab=#net12}
N 760 -250 760 -240 {lab=PC2}
N 760 -240 830 -240 {lab=PC2}
N 900 -260 900 -240 {lab=PC1}
N 850 -240 900 -240 {lab=PC1}
N 1340 -240 2000 -240 {lab=CLK}
N 20 -270 20 -230 {lab=#net13}
N 110 -260 110 -230 {lab=PC1}
N 240 -250 240 -230 {lab=PC2}
N 330 -270 330 -230 {lab=#net13}
N 760 -240 760 -230 {lab=PC2}
N 900 -240 900 -230 {lab=PC1}
N -310 -240 -310 -220 {lab=GND}
N 2730 -250 2730 -220 {lab=#net11}
N -30 -200 -20 -200 {lab=IN}
N 40 -370 40 -200 {lab=VDD}
N 20 -200 40 -200 {lab=VDD}
N 60 -200 70 -200 {lab=IN}
N 110 -200 190 -200 {lab=GND}
N 190 -200 240 -200 {lab=GND}
N 280 -200 290 -200 {lab=REF}
N 310 -370 310 -200 {lab=VDD}
N 310 -200 330 -200 {lab=VDD}
N 370 -200 380 -200 {lab=REF}
N 690 -200 720 -200 {lab=#net16}
N 760 -200 780 -200 {lab=GND}
N 780 -200 880 -200 {lab=GND}
N 880 -200 900 -200 {lab=GND}
N 940 -200 970 -200 {lab=#net16}
N 2410 -260 2410 -200 {lab=#net10}
N 2410 -200 2470 -200 {lab=#net10}
N 2940 -260 2940 -200 {lab=#net15}
N 2890 -200 2940 -200 {lab=#net15}
N 2940 -200 3010 -200 {lab=#net15}
N 1100 -250 1100 -180 {lab=PC2}
N 1100 -180 2020 -180 {lab=PC2}
N 2630 -180 2730 -180 {lab=#net17}
N 3320 -180 3370 -180 {lab=#net18}
N 3480 -180 3560 -180 {lab=#net19}
N 3670 -180 3780 -180 {lab=#net20}
N 3890 -180 4020 -180 {lab=#net21}
N 4130 -180 4160 -180 {lab=OUT2}
N 4160 -180 4190 -180 {lab=OUT2}
N 110 -170 170 -170 {lab=#net22}
N 170 -170 240 -170 {lab=#net22}
N 330 -170 640 -170 {lab=NC1}
N 640 -170 760 -170 {lab=NC1}
N 850 -240 850 -160 {lab=PC1}
N 810 -160 850 -160 {lab=PC1}
N 2970 -160 3010 -160 {lab=#net23}
N 780 -200 780 -150 {lab=GND}
N 740 -150 780 -150 {lab=GND}
N 880 -200 880 -150 {lab=GND}
N 880 -150 920 -150 {lab=GND}
N -30 -200 -30 -140 {lab=IN}
N -360 -140 -30 -140 {lab=IN}
N 60 -200 60 -140 {lab=IN}
N -30 -140 60 -140 {lab=IN}
N 1830 -380 1830 -140 {lab=#net2}
N 1830 -140 1840 -140 {lab=#net2}
N 1950 -140 2020 -140 {lab=#net24}
N 20 -170 20 -130 {lab=NC2}
N 20 -130 670 -130 {lab=NC2}
N 900 -170 900 -130 {lab=NC2}
N 670 -130 900 -130 {lab=NC2}
N 290 -200 290 -120 {lab=REF}
N -290 -120 290 -120 {lab=REF}
N 380 -200 380 -120 {lab=REF}
N 290 -120 380 -120 {lab=REF}
N 760 -170 760 -110 {lab=NC1}
N 900 -130 900 -110 {lab=NC2}
N 2720 -90 2760 -90 {lab=PD}
N 2970 -160 2970 -90 {lab=#net23}
N 2870 -90 2970 -90 {lab=#net23}
N 740 -150 740 -80 {lab=GND}
N 740 -80 760 -80 {lab=GND}
N 810 -160 810 -80 {lab=PC1}
N 800 -80 810 -80 {lab=PC1}
N 830 -240 830 -80 {lab=PC2}
N 830 -80 860 -80 {lab=PC2}
N 920 -150 920 -80 {lab=GND}
N 900 -80 920 -80 {lab=GND}
N -180 -300 -180 -70 {lab=PD}
N -180 -70 -130 -70 {lab=PD}
N 740 -80 740 -40 {lab=GND}
N 760 -50 760 -40 {lab=GND}
N 740 -40 760 -40 {lab=GND}
N 760 -40 830 -40 {lab=GND}
N 900 -50 900 -40 {lab=GND}
N 830 -40 900 -40 {lab=GND}
N 920 -80 920 -40 {lab=GND}
N 900 -40 920 -40 {lab=GND}
N -230 -30 -160 -30 {lab=#net25}
N -100 -30 -90 -30 {lab=#net26}
N -90 -30 -90 -20 {lab=#net26}
N -90 -20 -50 -20 {lab=#net26}
N 830 -40 830 -20 {lab=GND}
N -90 -20 -90 -10 {lab=#net26}
N 170 -170 170 -10 {lab=#net22}
N 170 -10 170 0 {lab=#net22}
N -110 20 -90 20 {lab=GND}
N -50 -20 -50 20 {lab=#net26}
N -50 20 40 20 {lab=#net26}
N 40 20 130 20 {lab=#net26}
N 190 -200 190 20 {lab=GND}
N 170 20 190 20 {lab=GND}
N -40 50 0 50 {lab=#net27}
N 40 50 70 50 {lab=GND}
N -130 -30 -130 80 {lab=GND}
N -110 20 -110 80 {lab=GND}
N -130 80 -110 80 {lab=GND}
N -90 50 -90 80 {lab=GND}
N -110 80 -90 80 {lab=GND}
N -90 80 40 80 {lab=GND}
N 70 50 70 80 {lab=GND}
N 40 80 70 80 {lab=GND}
N 170 50 170 80 {lab=GND}
N 70 80 170 80 {lab=GND}
N 190 20 190 80 {lab=GND}
N 170 80 190 80 {lab=GND}
N 40 80 40 100 {lab=GND}
N 230 180 290 180 {lab=PD}
N -520 -300 -520 190 {lab=PD}
N -520 190 -480 190 {lab=PD}
N -40 50 -40 190 {lab=#net27}
N -370 190 -40 190 {lab=#net27}
N 450 200 510 200 {lab=#net28}
N 690 -200 690 200 {lab=#net16}
N 620 200 690 200 {lab=#net16}
N 970 -200 970 200 {lab=#net16}
N 690 200 970 200 {lab=#net16}
N 230 220 290 220 {lab=CLK}
N 3150 -180 3210 -180 {lab=#net29}
N 3150 -340 3210 -340 {lab=#net30}
N 2340 -160 2470 -160 {lab=#net31}
N 2160 -160 2230 -160 {lab=#net32}
N -360 -120 -290 -120 {lab=REF}
N -220 -240 -160 -240 {lab=#net33}
N -310 -30 -290 -30 {lab=VDD}
N 400 -440 400 -430 {lab=VDD}
N -130 -240 -130 -220 {lab=GND}
C {iopin.sym} 1080 -260 0 1 {name=p1 lab=PC1
}
C {iopin.sym} 1050 -250 0 1 {name=p2 lab=PC2
}
C {iopin.sym} 640 -170 0 1 {name=p3 lab=NC1
}
C {iopin.sym} 670 -130 0 1 {name=p4 lab=NC2
}
C {iopin.sym} 1340 -400 0 1 {name=p12 lab=RST
}
C {iopin.sym} 1340 -240 0 1 {name=p13 lab=CLK
}
C {iopin.sym} -560 -300 0 1 {name=p17 lab=PD
}
C {iopin.sym} 1340 -360 0 1 {name=p18 lab=PD
}
C {iopin.sym} 500 -330 0 1 {name=p22 lab=CLK
}
C {iopin.sym} 230 180 0 1 {name=p23 lab=PD
}
C {iopin.sym} 230 220 0 1 {name=p24 lab=CLK
}
C {iopin.sym} 2930 -360 0 1 {name=p25 lab=PD
}
C {iopin.sym} 2720 -90 0 1 {name=p26 lab=PD
}
C {PMOS_MIN.sym} 800 -330 0 1 {name=M1 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {NMOS_MIN.sym} 860 -80 0 0 {name=M2 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {NMOS_MIN.sym} 130 20 0 0 {name=M3 l=0.35u w=10u ad=17.5e-12 as=17.5e-12 pd=13.5e-6 ps=13.5e-6 m=1}
C {NMOS_MIN.sym} -50 20 0 1 {name=M4 l=0.35u w=1u ad=1.75e-12 as=1.75e-12 pd=4.5e-6 ps=4.5e-6 m=1}
C {PMOS_MIN.sym} -50 -310 0 1 {name=M5 l=0.35u w=3u ad=5.25e-12 as=5.25e-12 pd=6.5e-6 ps=6.5e-6 m=1}
C {PMOS_MIN.sym} 140 -310 0 0 {name=M6 l=0.35u w=30u ad=52.5e-12 as=52.5e-12 pd=33.5e-6 ps=33.5e-6 m=1}
C {NMOS_MIN.sym} 720 -200 0 0 {name=M7 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {NMOS_MIN.sym} 940 -200 0 1 {name=M8 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {NMOS_MIN.sym} 800 -80 0 1 {name=M9 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {PMOS_MIN.sym} 1030 -330 0 1 {name=M10 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {PMOS_MIN.sym} 860 -330 0 0 {name=M11 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {PMOS_MIN.sym} 620 -330 0 0 {name=M12 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {NMOS_MIN.sym} 70 -200 0 0 {name=M13 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {NMOS_MIN.sym} 280 -200 0 1 {name=M14 l=0.35u w=14u ad=24.5e-12 as=24.5e-12 pd=17.5e-6 ps=17.5e-6 m=1}
C {PMOS_MIN.sym} -20 -200 0 0 {name=M15 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {PMOS_MIN.sym} 370 -200 0 1 {name=M16 l=0.35u w=21u ad=36.8e-12 as=36.8e-12 pd=24.5e-6 ps=24.5e-6 m=1}
C {PMOS_MIN.sym} -40 -340 0 0 {name=M17 l=0.35u w=1.4u ad=1.2p as=1.2p pd=4.6u ps=4.6u m=1}
C {NMOS_MIN.sym} 0 50 0 0 {name=M18 l=0.35u w=0.7u ad=0.56p as=0.56p pd=3u ps=3u m=1}
C {NMOS_MIN.sym} -130 -70 1 0 {name=M19 l=0.35u w=0.7u ad=0.56p as=0.56p pd=3u ps=3u m=1}
C {NMOS_MIN.sym} -130 -280 1 0 {name=M20 l=0.35u w=0.7u ad=0.56p as=0.56p pd=3u ps=3u m=1}
C {Clocked_Comparator_Xschem/INVERTER18.sym} 4130 -330 0 0 {name=x1}
C {Clocked_Comparator_Xschem/INVERTER18.sym} 4130 -170 0 0 {name=x2}
C {Clocked_Comparator_Xschem/INVERTER9.sym} 3890 -330 0 0 {name=x3}
C {Clocked_Comparator_Xschem/INVERTER9.sym} 3890 -170 0 0 {name=x4}
C {Clocked_Comparator_Xschem/INVERTER3.sym} 3670 -330 0 0 {name=x5}
C {Clocked_Comparator_Xschem/INVERTER3.sym} 3670 -170 0 0 {name=x6}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 3480 -330 0 0 {name=x7}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 3480 -170 0 0 {name=x8}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 3320 -330 0 0 {name=x9}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 3320 -170 0 0 {name=x10}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 2870 -80 0 0 {name=x11}
C {Clocked_Comparator_Xschem/NAND2.sym} 3040 -320 0 0 {name=x12}
C {Clocked_Comparator_Xschem/NOR2.sym} 3130 -170 0 0 {name=x13}
C {Clocked_Comparator_Xschem/NAND2.sym} 2780 -300 0 0 {name=x14}
C {Clocked_Comparator_Xschem/NAND2.sym} 2780 -180 0 0 {name=x15}
C {Clocked_Comparator_Xschem/NAND2.sym} 2520 -320 0 0 {name=x16}
C {Clocked_Comparator_Xschem/NAND2.sym} 2520 -160 0 0 {name=x17}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 2340 -150 0 0 {name=x18}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 2340 -250 0 0 {name=x19}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 2340 -350 0 0 {name=x20}
C {Clocked_Comparator_Xschem/NAND2.sym} 2050 -340 0 0 {name=x21}
C {Clocked_Comparator_Xschem/NAND2.sym} 2050 -240 0 0 {name=x22}
C {Clocked_Comparator_Xschem/NOR2.sym} 2140 -150 0 0 {name=x23}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 1960 -130 0 0 {name=x24}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 1790 -370 0 0 {name=x25}
C {Clocked_Comparator_Xschem/NAND2.sym} 1510 -360 0 0 {name=x26}
C {Clocked_Comparator_Xschem/NAND2.sym} 340 220 0 0 {name=x27}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} 620 210 0 0 {name=x28}
C {Clocked_Comparator_Xschem/INVERTER_MIN.sym} -370 200 0 0 {name=x29}
C {isource.sym} -250 -240 1 0 {name=I0 value=10u}
C {isource.sym} -260 -30 3 0 {name=I1 value=10u}
C {gnd.sym} 40 100 0 0 {name=l2 lab=GND}
C {ipin.sym} -360 -140 0 0 {name=p6 lab=IN}
C {opin.sym} 4190 -340 0 0 {name=p7 lab=OUT1
}
C {vdd.sym} 400 -440 0 0 {name=l3 lab=VDD}
C {lab_wire.sym} 480 -430 0 0 {name=p16 sig_type=std_logic lab=VDD}
C {gnd.sym} -310 -220 0 0 {name=l1 lab=GND}
C {ipin.sym} -360 -120 0 0 {name=p5 lab=REF}
C {vdd.sym} -310 -30 0 0 {name=l4 lab=VDD}
C {gnd.sym} 830 -20 0 0 {name=l5 lab=GND}
C {opin.sym} 4190 -180 0 0 {name=p8 lab=OUT2
}
C {gnd.sym} -130 -220 0 0 {name=l6 lab=GND}
C {code_shown.sym} -545 340 0 0 {name=spice only_toplevel=false value="

.inc /home/hnriv/MOSMODEL/OCS65_model.para
VVDD VDD 0 DC 3.3

*VIN IN 0 pwl (0 0 25n 0 26n 3.3 75n 3.3 76n 0.2 125n 0.2 126n 3.1 175n 3.1 176n 0.4 225n 0.4 226n 2.9 275n 2.9 276n 0.6 325n 0.6 326n 2.7 375n 2.7 376n 0.8 425n 0.8 426n 2.5 475n 2.5 476n 1.0 525n 1.0 526n 2.3 575n 2.3 576n 1.2 625n 1.2 626n 2.1 675n 2.1 676n 1.4 725n 1.4 726n 1.9 775n 1.9 776n 1.6 825n 1.6 826n 1.7 875n 1.7) 
*VIN IN 0 pwl (0 2.15 25n 2.15 26n 1.15 75n 1.15 76n 1.95 125n 1.95 126n 1.35 175n 1.35)
*VIN IN 0 pwl (0 1.85 25n 1.85 26n 1.45 75n 1.45 76n 1.83 125n 1.83 126n 1.47 175n 1.47)


*VIN IN 0 pulse (1.6502 1.6498 0 1p 1p 40n 80n)

*VIN IN 0 pulse (1.6501 1.6499 0 1p 1p 100n 200n)

VIN  IN 0 pwl (0 1.64 1000n 1.66) 


*VRST RST 0 pulse(3.3 0 5n 1n 1n 2000n 4000n
VRST RST 0 dc 3.3
VPD  PD  0 dc 3.3
VREF REF 0 DC 1.65
VCLK CLK 0 pulse(0 3.3 50n 1n 1n 50n 100n)

.control
tran 1n 1000n

meas tran delayIN1 find time WHEN v(CLK)=0.9 RISE=3 
meas tran delayOUT find time WHEN v(OUT1)=0.9 FALL=2
let delay1 = delayOUT - delayIN1
echo tpHL = $&delay1

meas tran delayIN1 find time WHEN v(CLK)=0.9 RISE=4 
meas tran delayOUT find time WHEN v(OUT1)=0.9 RISE=2
let delay2 = delayOUT - delayIN1
echo tpLH = $&delay2


meas TRAN Iavg AVG I(VVDD)


*plot v(OUT1)
*plot v(IN)
*plot v(CLK)
*plot v(NC1)
*plot v(NC2)
*plot v(PC1)
*plot v(PC2)

write "Wide-swing_clocked_comparator.raw"

.endc"}
