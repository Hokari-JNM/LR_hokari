v {xschem version=3.4.7RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 1030 -120 1030 -90 {lab=#net1}
N 1030 -120 1220 -220 {lab=#net1}
N 1030 -210 1030 -180 {lab=#net2}
N 1030 -180 1220 -80 {lab=#net2}
N 920 -230 1030 -230 {lab=#net3}
N 830 -220 830 -80 {lab=#net4}
N 780 -150 830 -150 {lab=#net4}
N 650 -150 680 -150 {lab=#net5}
N 510 -140 560 -140 {lab=CLK}
N 1120 -80 1240 -80 {lab=#net2}
N 1120 -220 1240 -220 {lab=#net1}
N 1340 -220 1380 -220 {lab=#net6}
N 1340 -80 1380 -80 {lab=#net7}
N 1480 -220 1520 -220 {lab=Q2}
N 1480 -80 1520 -80 {lab=Q1}
N 650 -240 680 -240 {lab=#net8}
N 510 -230 560 -230 {lab=R}
N 440 -250 560 -250 {lab=#net9}
N 780 -240 830 -240 {lab=#net10}
N 510 -70 560 -70 {lab=S}
N 650 -60 680 -60 {lab=#net11}
N 780 -60 830 -60 {lab=#net12}
N 480 -50 560 -50 {lab=#net13}
N 360 -250 440 -250 {lab=#net9}
N 380 -250 380 -50 {lab=#net9}
N 920 -70 1030 -70 {lab=#net14}
N 200 -250 230 -250 {lab=#net15}
N 60 -240 110 -240 {lab=PD}
N 60 -260 110 -260 {lab=RST}
N 330 -250 360 -250 {lab=#net9}
N 60 -240 60 -160 {lab=PD}
N 60 -160 560 -160 {lab=PD}
C {ipin.sym} 60 -260 0 0 {name=p1 lab=RST}
C {ipin.sym} 510 -70 0 0 {name=p2 lab=S}
C {ipin.sym} 510 -140 0 0 {name=p3 lab=CLK}
C {opin.sym} 1520 -220 0 0 {name=p4 lab=Q2}
C {LR_Work2/NAND2.sym} 980 -230 0 0 {name=x1}
C {LR_Work2/NAND2.sym} 980 -70 0 0 {name=x2}
C {LR_Work2/NAND2.sym} 1180 -220 0 0 {name=x3}
C {LR_Work2/NAND2.sym} 1180 -80 0 0 {name=x4}
C {opin.sym} 1520 -80 0 0 {name=p5 lab=Q1}
C {ipin.sym} 510 -230 0 0 {name=p6 lab=R}
C {LR_Work2/NAND2.sym} 710 -150 0 0 {name=x5}
C {LR_Work2/symbol/INVERTER.sym} 1480 -80 0 0 {name=x6}
C {ipin.sym} 60 -160 0 0 {name=p7 lab=PD}
C {LR_Work2/symbol/INVERTER.sym} 920 -150 0 0 {name=x7}
C {LR_Work2/symbol/INVERTER.sym} 1620 -80 0 0 {name=x8}
C {LR_Work2/symbol/INVERTER.sym} 1480 -220 0 0 {name=x9}
C {LR_Work2/symbol/INVERTER.sym} 1620 -220 0 0 {name=x10}
C {LR_Work2/NAND2.sym} 710 -240 0 0 {name=x11}
C {LR_Work2/symbol/INVERTER.sym} 920 -240 0 0 {name=x12}
C {LR_Work2/symbol/INVERTER.sym} 920 -60 0 0 {name=x14}
C {LR_Work2/symbol/INVERTER.sym} 620 -50 0 0 {name=x15}
C {LR_Work2/NAND2.sym} 260 -250 0 0 {name=x16}
C {LR_Work2/symbol/INVERTER.sym} 470 -250 0 0 {name=x17}
C {LR_Work2/NOR2.sym} 700 0 0 0 {name=x13}
